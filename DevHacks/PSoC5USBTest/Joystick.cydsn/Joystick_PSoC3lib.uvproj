# Keil uVision project Joystick_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Joystick_PSoC3lib (library)
  c flags: Optimize=5
  c misc: PR(${OutputDir}/${CompileFile}.lst) MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c AMux_1.c AMux_1.h X_Input.c X_Input.h X_Input_aliases.h Y_Input.c Y_Input.h Y_Input_aliases.h LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c USBFS_1.c USBFS_1.h USBFS_1_audio.c USBFS_1_audio.h USBFS_1_boot.c USBFS_1_cdc.c USBFS_1_cdc.h USBFS_1_cls.c USBFS_1_descr.c USBFS_1_drv.c USBFS_1_episr.c USBFS_1_hid.c USBFS_1_hid.h USBFS_1_pm.c USBFS_1_std.c USBFS_1_vnd.c USBFS_1_cdc.inf USBFS_1_midi.c USBFS_1_midi.h USBFS_1_pvt.h Button_A.c Button_A.h Button_A_aliases.h Button_B.c Button_B.h Button_B_aliases.h Button_C.c Button_C.h Button_C_aliases.h Button_D.c Button_D.h Button_D_aliases.h Thumb_Button.c Thumb_Button.h Thumb_Button_aliases.h ADC_DelSig_1_AMux.c ADC_DelSig_1_AMux.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h ADC_DelSig_1_IRQ.c ADC_DelSig_1_IRQ.h ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h LCD_Char_1_LCDPort_aliases.h USBFS_1_Dm.c USBFS_1_Dm.h USBFS_1_Dm_aliases.h USBFS_1_Dp.c USBFS_1_Dp.h USBFS_1_Dp_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Joystick_PSoC3lib (library)
  c flags: Optimize=5
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
